# Keil uVision project FreeRTOS.uvproj, settings and files
target nuc980_freertos_lwip (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: FreeRTOS_LwIP +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\Src\Driver\Include;..\Src\Core\freertos;..\Src\Core\freertos\portable\RVDS\ARM9_NUC980;..\Src\Lib\FreeRTOS\Source\include;..\Src\Lib\FreeRTOS\Demo\Common\include
  asm include: ..\Src\Core\freertos\portable\RVDS\ARM9_NUC980
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: nuc980.sct
  link misc: --entry 0x8000
  group Core
    ../Src/Core/: main.c multithread.c
  group Drivers
    ../Src/Driver/Source/: sys.c cache.c uart.c retarget.c
  group Startup
    ../Src/Startup/: startup_keil.s
    ../Src/Driver/Source/: vector.s
  group FreeRTOS
    ../Src/Core/freertos/portable/RVDS/ARM9_NUC980/: port.c portASM.s
    ../Src/Core/freertos/portable/MemMang/: heap_2.c
    ../Src/Lib/FreeRTOS/Source/: list.c queue.c tasks.c timers.c stream_buffer.c
    ../Src/Lib/FreeRTOS/Demo/Common/Minimal/: BlockQ.c PollQ.c semtest.c
